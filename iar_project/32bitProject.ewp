# IAR project 32bitProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include; ..\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include; $PROJ_DIR$; ..\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery; C:\Users\lazarc\Documents\32bit\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 32bitProject.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: 32bitProject.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
